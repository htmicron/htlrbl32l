# Keil uVision project PushButton_LoRaWAN-Bluetooth.uvprojx, settings and files
target PushButton_LoRaWAN-Bluetooth (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PushButton_LoRaWAN-Bluetooth +hex
  AfterMake: fromelf.exe --bin Objects\PushButton_LoRaWAN-Bluetooth.axf --output ..\..\Binary\PushButton_LoRaWAN-Bluetooth.bin
  AfterMake: fromelf.exe --bin Objects\PushButton_LoRaWAN-Bluetooth.axf --output ..\..\..\..\Binaries\PushButton_LoRaWAN-Bluetooth.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_HW_HSE_TUNE=32 CONFIG_HW_SMPS_10uH CONFIG_HW_LS_RO DEFAULT_REGION=5 USE_FULL_LL_DRIVER BLE_STACK_BASIC_CONF PUSH_BUTTON_APP
  c include: ..\..\Inc;..\..\HT_BLE_API\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\hal\inc;..\..\..\..\HTLRBL32L-SDK\Drivers\CMSIS\Include;..\..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Core\Inc;..\..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Crypto\Inc;..\..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Mac\Inc;..\..\..\..\HTLRBL32L-SDK\LoRaWAN\lorawan_specifics\Mac\Region\Inc;..\..\..\..\HTLRBL32L-SDK\LoRaWAN\Utils\Inc;..\..\..\..\HTLRBL32L-SDK\LoRaWAN\sx126x\Inc;..\..\..\..\HTLRBL32L-SDK\Drivers\Peripherals_Drivers\Inc;..\..\..\..\HTLRBL32L-SDK\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\RNGMGR\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\PKAMGR\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\AESMGR\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\BLECNTR\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\Bluetooth_LE\inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\NVMDB\Inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\cryptolib\inc;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\cryptolib\inc\AES;..\..\..\..\HTLRBL32L-SDK\Middlewares\ST\cryptolib\inc\Common
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\BlueNRG_LP.sct
  link misc: --verbose
  group Application/User
    ../../Src/: main.c spi.c uart.c rtc.c lorawan_setup.c bluenrg_lp_it.c gpio.c HT_push_button.c
  group HT_BLE_API/Src
    ../../HT_BLE_API/Src/: HT_ble_api.c HT_gatt_db.c
  group Libraries/LoRaWAN/Core
    ../../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Core/Src/: lora.c lora-test.c
  group Libraries/LoRaWAN/Crypto
    ../../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Crypto/Src/: aes.c cmac.c soft-se.c
  group Libraries/LoRaWAN/MAC
    ../../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Mac/Src/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Libraries/LoRaWAN/MAC/Region
    ../../../../HTLRBL32L-SDK/LoRaWAN/lorawan_specifics/Mac/Region/Src/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Libraries/sx126x
    ../../../../HTLRBL32L-SDK/LoRaWAN/SX126X/Src/: radio.c sx126x.c sx1262_interface.c
  group Libraries/Utils
    ../../../../HTLRBL32L-SDK/LoRaWAN/Utils/Src/: hal_wrappers.c systime.c timeServer.c utils.c
  group Libraries/Peripheral_Drivers
    ../../../../HTLRBL32L-SDK/Drivers/Peripherals_Drivers/src/: rf_driver_hal.c rf_driver_hal_adc.c rf_driver_hal_cortex.c rf_driver_hal_dma.c rf_driver_hal_exti.c rf_driver_hal_flash.c rf_driver_hal_gpio.c rf_driver_hal_rcc.c rf_driver_hal_rtc.c rf_driver_hal_spi.c rf_driver_hal_tim.c rf_driver_hal_uart.c rf_driver_hal_flash_ex.c rf_driver_hal_rtc_ex.c rf_driver_hal_uart_ex.c rf_driver_hal_power_manager.c rf_driver_ll_rcc.c
    ../../../../HTLRBL32L-SDK/Drivers/Peripherals_Drivers/Src/: rf_driver_hal_radio_2g4.c rf_driver_hal_vtimer.c rf_driver_ll_radio_2g4.c rf_driver_ll_tim.c rf_driver_ll_pka_v7b.c rf_driver_ll_flash.c rf_driver_ll_timer.c
  group Libraries/CMSIS
    ../../../../HTLRBL32L-SDK/Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Libraries/HAL
    ../../../../HTLRBL32L-SDK/Middlewares/ST/hal/Src/: clock.c fifo.c gp_timer.c hal_miscutil.c osal.c blue_unit_conversion.s context_switch.s osal_memcpy.s miscutil.c
  group Libraries/Crypto
    ../../../../HTLRBL32L-SDK/Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
    ../../../../HTLRBL32L-SDK/Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Libraries/BLECNTR
    ../../../../HTLRBL32L-SDK/Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Libraries/NVM
    ../../../../HTLRBL32L-SDK/Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Libraries/PKA
    ../../../../HTLRBL32L-SDK/Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Libraries/Profiles
    ../../../../HTLRBL32L-SDK/Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Libraries/RNG
    ../../../../HTLRBL32L-SDK/Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
  group Libraries/BLE_Stack
    ../../../../HTLRBL32L-SDK/Middlewares/ST/Bluetooth_LE/library/: libbluenrg_lp_stack.a
    ../../../../HTLRBL32L-SDK/Middlewares/ST/Bluetooth_LE/src/: stack_user_cfg.c
software components: CMSIS:CORE 5.3.0
